# Keil uVision project Prepaid_Interface_Test.uvproj, settings and files
target PREPAY_V0_Modbus_Bridge (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: PREPAY_V0_Modbus_Bridge +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7
  c include: .\src;vendor\MS51_BSP\MS51FC0AE_MS51XC0BE_MS51EB0AE_MS51EC0AE_MS51TC0AE_MS51PC0AE\Library\Device\Include;vendor\MS51_BSP\MS51FC0AE_MS51XC0BE_MS51EB0AE_MS51EC0AE_MS51TC0AE_MS51PC0AE\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Modbus Energy Bridge
    ./src/: main.c board_io.c board_io.h i2c_probe.c i2c_probe.h lcd_595.c lcd_595.h lcd_ui.c lcd_ui.h rs485_test.c rs485_test.h
  group Nuvoton BSP Drivers
    vendor/MS51_BSP/MS51FC0AE_MS51XC0BE_MS51EB0AE_MS51EC0AE_MS51TC0AE_MS51PC0AE/Library/StdDriver/src/: common.c sys.c uart.c delay.c
  group Startup
    vendor/MS51_BSP/MS51FC0AE_MS51XC0BE_MS51EB0AE_MS51EC0AE_MS51TC0AE_MS51PC0AE/Library/Startup/KEIL/: STARTUP.A51
